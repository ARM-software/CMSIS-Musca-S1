# Keil uVision project Blinky.uvprojx, settings and files
target Debug (eMRAM) (6120000::V6.12::.\ARMCLANG)
  device: Musca-S1:CM33-0 ARM
  pack: ARM.Musca-S1_DFP.1.0.0
  cpu: IRAM(0x30000000,0x00020000) IRAM2(0x20000000,0x00020000) IROM(0x10200000,0x00040000) IROM2(0x00200000,0x00040000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ESEL ELITTLE
  output: Blinky +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: MRAM
  c misc: -Wno-dollar-in-identifier-extension
  c include: .\x_BoardSupport
  memory RVCT4: ROM 0x10200000 size 0x40000
  memory RVCT5: ROM 0x200000 size 0x40000
  memory RVCT9: RAM 0x30000000 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: .\RTE\Device\Musca-S1_CM33-0\armcc6_arm.sct
  link misc: --predefine="-DMRAM"
  group Documentation
    ./: Abstract.txt
  group Source Files
    ./: main.c Blinky.c
target Debug (SRAM) (6120000::V6.12::.\ARMCLANG)
  device: Musca-S1:CM33-0 ARM
  pack: ARM.Musca-S1_DFP.1.0.0
  cpu: as above
  output: Blinky +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: SRAM
  c misc: -Wno-dollar-in-identifier-extension
  c include: .\x_BoardSupport
  memory RVCT4: ROM 0x10200000 size 0x40000
  memory RVCT5: ROM 0x200000 size 0x40000
  memory RVCT9: RAM 0x30000000 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: .\RTE\Device\Musca-S1_CM33-0\armcc6_arm.sct
  link misc: --predefine="-DSRAM"
software components: Board Support:LED 1.0.0, CMSIS:CORE 5.2.0, CMSIS:RTOS2:Keil RTX5 5.5.0, Device:Startup 1.0.0
