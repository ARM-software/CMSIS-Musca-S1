# Keil uVision project MT25.uvproj, settings and files
target MT25QL512 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3") ESEL ELITTLE
  output: MT25QL512
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=1 v6Lang=1 v6LangP=1
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
  group Program Functions
    ./: FlashPrg.c
  group Device Description
    ./: FlashDev.c
  group Device Driver
    ./: Flash_QSPI.c
target MT25QL512_DC (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3") ESEL ELITTLE
  output: MT25QL512_DC
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: SET_DC
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
