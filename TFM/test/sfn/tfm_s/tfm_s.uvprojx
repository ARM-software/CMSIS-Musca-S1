# Keil uVision project tfm_s.uvprojx, settings and files
target Musca-S1_MRAM (6140000::V6.14::ARMCLANG)
  device: Musca-S1:CM33-0 ARM
  pack: ARM.Musca-S1_DFP.1.2.0-dev0-tfm
  cpu: IRAM(0x00000000,0x00200000) IRAM2(0x0A000000,0x00200000) IROM(0x00200000,0x02000000) IROM2(0x0E000000,0x00000400) XRAM(0x10000000,0x00200000) XRAM2(0x1A000000,0x00200000) XRAM3(0x20000000,0x00080000) XROM(0x10200000,0x02000000) XROM2(0x1E000000,0x00000400) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ESEL ELITTLE
  output: tfm_s
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  memory RVCT1: ROM 0x10200000 size 0x2000000
  memory RVCT2: ROM 0x1e000000 size 0x400
  memory RVCT4: ROM 0x200000 size 0x2000000
  memory RVCT5: ROM 0xe000000 size 0x400
  memory RVCT6: RAM 0x10000000 size 0x200000
  memory RVCT7: RAM 0x1a000000 size 0x200000
  memory RVCT8: RAM 0x20000000 size 0x80000
  memory RVCT9: RAM 0x0 size 0x200000
  memory RVCT10: RAM 0xa000000 size 0x200000
  scatter file: .\RTE\TFM\tfm_common_s.sct
  link misc: --import_cmse_lib_out="Objects/tfm_s_CMSE_Lib.o"
--predefine="-include tfm_config.h"
--predefine="-include tfm_config_rte.h"
--predefine="-IRTE/_Musca-S1_MRAM/"
--predefine="-IRTE/TFM_Platform/Musca-S1_CM33-0/"
--diag_suppress=L6312,L6314,L6329
  group System Files
    ./: Driver_USART.c
software components: CMSIS Driver:Flash:MRAM 1.1.0, CMSIS Driver:USART:Custom 1.0.0, CMSIS:CORE 5.4.0, Device:Startup 2.0.0, Security:mbed Crypto 3.0.1, TFM Platform:Attest HAL:Template 1.0.0, TFM Platform:Boot Seed:Dummy 1.0.0, TFM Platform:Crypto Keys:Dummy 1.0.0, TFM Platform:Device ID:Dummy 1.0.0, TFM Platform:Memory Map 1.0.0, TFM Platform:NV Counters:Dummy 1.0.0, TFM Platform:SPM HAL:Platform 1.0.0, TFM Platform:System:Template 1.0.0, TFM Platform:Test:Platform 1.0.0, TFM:Core 1.0.0, TFM:Library:QCBOR 1.0.0, TFM:Library:T_COSE 1.0.0, TFM:Secure Service:Audit Logging 1.0.0, TFM:Secure Service:Crypto 1.0.0, TFM:Secure Service:Initial Attestation 1.0.0, TFM:Secure Service:Internal Trusted Storage 1.0.0, TFM:Secure Service:Platform 1.0.0, TFM:Secure Service:Secure Storage 1.0.0, TFM:Test Service:Core 1.0.0, TFM:Test Service:IRQ 1.0.0, TFM:Test Service:SST 1.0.0, TFM:Test Service:Secure Client 1.0.0, TFM:Test:Attestation 1.0.0, TFM:Test:Audit 1.0.0, TFM:Test:Crypto 1.0.0, TFM:Test:Framework 1.0.0, TFM:Test:ITS 1.0.0, TFM:Test:Platform 1.0.0, TFM:Test:SST 1.0.0
