# Keil uVision project tfm_ns.uvprojx, settings and files
target Musca-S1_MRAM (6140000::V6.14::ARMCLANG)
  device: Musca-S1:CM33-0 ARM
  pack: ARM.Musca-S1_DFP.1.2.0-dev0-tfm
  cpu: IRAM(0x00000000,0x00200000) IRAM2(0x0A000000,0x00200000) IROM(0x00200000,0x02000000) IROM2(0x0E000000,0x00000400) XRAM(0x10000000,0x00200000) XRAM2(0x1A000000,0x00200000) XRAM3(0x20000000,0x00080000) XROM(0x10200000,0x02000000) XROM2(0x1E000000,0x00000400) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ESEL ELITTLE
  output: tfm_ns
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  memory RVCT1: ROM 0x10200000 size 0x2000000
  memory RVCT2: ROM 0x1e000000 size 0x400
  memory RVCT4: ROM 0x200000 size 0x2000000
  memory RVCT5: ROM 0xe000000 size 0x400
  memory RVCT6: RAM 0x10000000 size 0x200000
  memory RVCT7: RAM 0x1a000000 size 0x200000
  memory RVCT8: RAM 0x20000000 size 0x80000
  memory RVCT9: RAM 0x0 size 0x200000
  memory RVCT10: RAM 0xa000000 size 0x200000
  scatter file: .\RTE\Device\Musca-S1_CM33-0\armcc6_arm.sct
  link misc: --predefine="-I../tfm_s/RTE/TFM_Platform/Musca-S1_CM33-0/"
  group System Files
    ./: main.c
    ../tfm_s/Objects/: tfm_s_CMSE_Lib.o
software components: CMSIS Driver:USART 1.1.0, CMSIS:CORE 5.4.0, CMSIS:RTOS2:Keil RTX5 5.5.2, Device:Startup 2.0.0, TFM:API 1.0.0, TFM:Library:QCBOR 1.0.0, TFM:Library:T_COSE 1.0.0, TFM:Test:Attestation 1.0.0, TFM:Test:Audit 1.0.0, TFM:Test:Core Interactive 1.0.0, TFM:Test:Core Positive 1.0.0, TFM:Test:Crypto 1.0.0, TFM:Test:Framework 1.0.0, TFM:Test:ITS 1.0.0, TFM:Test:Platform 1.0.0, TFM:Test:QCBOR 1.0.0, TFM:Test:SST 1.0.0, TFM:Test:Secure Client 1.0.0, TFM:Test:T_COSE 1.0.0
